# Keil uVision project CH32F20X.uvprojx, settings and files
target CH32F20x (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: CH32F203CB WCH
  pack: Keil.WCH32F2xx_DFP.1.0.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CH32F20x +hex
  AfterMake: python .\ezboot\script\ota_generate.py  .\ezboot\config $L@L.hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\SRC\StdPeriphDriver\inc;.\SRC\CMSIS;.\SRC\Debug;.\rtthread\src;.\drivers;.\rtthread\libcpu\arm\common;.\rtthread\libcpu\arm\cortex-m3;.\rtthread\components\drivers\include;.\rtthread\components\drivers\misc;.\rtthread\components\drivers\serial;.\rtthread\components\finsh;.\rtthread\include;.\rtthread\include\libc;.\rtthread;.\components\sfud\inc;.\components\fal\inc;.\components\fal\porting;.\;.\app\inc;.\components\ymodem;.\ezboot\components\ezb_flash\inc;.\ezboot\components\ota_mgr\inc;.\ezboot\config;.\ezboot\components\norflash\inc;.\components\nvs\inc;.\ezboot\porting\mcu_header
  memory RVCT4: ROM 0x8004000 size 0x1c000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ./: ch32f20x_it.c Main.c system_ch32f20x.c
    ./app/src/: vuart.c ymodem_ota.c
  group startup
    ./SRC/Startup/: startup_ch32f20x_D8C.s
  group core
    ./SRC/CMSIS/: core_cm3.c
  group debug
    ./SRC/Debug/: debug.c
  group peripheral
    ./SRC/StdPeriphDriver/src/: ch32f20x_adc.c ch32f20x_bkp.c ch32f20x_can.c ch32f20x_crc.c ch32f20x_dac.c ch32f20x_dbgmcu.c ch32f20x_dma.c ch32f20x_dvp.c ch32f20x_eth.c ch32f20x_exti.c ch32f20x_flash.c ch32f20x_fsmc.c ch32f20x_gpio.c ch32f20x_i2c.c ch32f20x_iwdg.c ch32f20x_misc.c ch32f20x_opa.c ch32f20x_pwr.c ch32f20x_rcc.c ch32f20x_rng.c ch32f20x_rtc.c ch32f20x_sdio.c ch32f20x_spi.c ch32f20x_tim.c ch32f20x_usart.c ch32f20x_wwdg.c
  group DeviceDrivers
    ./rtthread/components/drivers/misc/: pin.c
    ./rtthread/components/drivers/serial/: serial.c
  group Drivers
    ./drivers/: drv_gpio.c drv_usart.c
    ./rtthread/: board.c
  group Kernel
    ./rtthread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group CPU
    ./rtthread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ./rtthread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group Finish
    ./rtthread/components/finsh/: cmd.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group compoents
    ./components/sfud/src/: sfud.c sfud_sfdp.c
    ./components/sfud/porting/: sfud_port.c
    ./components/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    ./components/fal/porting/: fal_flash_sfud_port.c fal_flash_ch32f2_port.c
    ./components/ymodem/: ymodem.c
  group ezboot
    ./ezboot/components/norflash/src/: norflash.c
    ./ezboot/components/ota_mgr/src/: ota_mgr_nvs.c
    ./ezboot/porting/ezb_flash/: ezb_flash.c
    ./ezboot/porting/mcu_header/: mcu_header.h
    ./ezboot/porting/norflash/: norflash_spi.c
    ./ezboot/config/: ezboot_config.h
