# Keil uVision project ezboot-app-example.uvprojx, settings and files
target ezboot-app-example (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: ezboot-app-example +hex
  AfterMake: python ..\ezboot\script\ota_generate.py "..\ezboot\config" "$L@L.hex"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,USER_VECT_TAB_ADDRESS
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../RT-Thread;../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/components/finsh/inc/;../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/include/;../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/include/libc/include/;../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/include/libc/extension/;../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/include/libc/extension/fcntl/msvc/;../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/include/libc/extension/fcntl/octal/;../components/ringbuffer;../components/ymodem;../ezboot/components/ezb_flash/inc;../ezboot/components/norflash/inc;../ezboot/components/ota_mgr/inc;../ezboot/config;../ezboot/porting/mcu_header;..\Middlewares\Third_Party\RealThread_RTOS_RT-Thread\bsp\_template\cubemx_config;..\Core\Inc
  memory RVCT4: ROM 0x8003800 size 0xe800
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c ymd_ota.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group components
    ../components/ringbuffer/: ringbuffer.c
    ../components/ymodem/: crc.c ymodem.c
  group ezboot
    ../ezboot/components/norflash/src/: norflash.c
    ../ezboot/components/ota_mgr/src/: ota_mgr_nvs.c
    ../ezboot/config/: ezboot_config.h
    ../ezboot/porting/ezb_flash/: ezb_flash.c
    ../ezboot/porting/mcu_header/: mcu_header.h
    ../ezboot/porting/norflash/: norflash_spi.c
  group Middlewares/RT-Thread/RTOS/shell
    ../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/components/finsh/src/: cmd.c msh.c msh_file.c msh_parse.c shell.c
  group Middlewares/RT-Thread/RTOS/libcpu
    ../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group Middlewares/RT-Thread/RTOS/kernel
    ../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
    ../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/bsp/_template/cubemx_config/: board.c
software components: CMSIS:CORE 4.3.0
